*** SPICE deck for cell Test_4_Comparator{lay} from library 4_bit_comparator
*** Created on Mon May 27, 2024 17:32:14
*** Last revised on Tue Jun 11, 2024 12:11:51
*** Written on Tue Jun 11, 2024 12:14:17 by Electric VLSI Design System, version 9.07
*** Layout tech: mocmos, foundry MOSIS
*** UC SPICE *** , MIN_RESIST 4.0, MIN_CAPAC 0.1FF

*** TOP LEVEL CELL: Test_4_Comparator{lay}
Mnmos@0 gnd_1 A3 net@10 gnd_28 NMOS L=1.2U W=6U AS=46.44P AD=84.24P PS=45.6U PD=74.4U
Mnmos@1 gnd B3 net@14 gnd_28 NMOS L=1.2U W=6U AS=46.44P AD=84.24P PS=45.6U PD=74.4U
Mnmos@13 gnd_2 net@10 net@329 gnd_28 NMOS L=1.2U W=12U AS=23.22P AD=117.54P PS=27.6U PD=99U
Mnmos@14 net@329 B3 net@344 gnd_28 NMOS L=1.2U W=12U AS=49.02P AD=23.22P PS=47.8U PD=27.6U
Mnmos@15 gnd_2 net@344 net@349 gnd_28 NMOS L=1.2U W=6U AS=46.44P AD=117.54P PS=45.6U PD=99U
Mnmos@31 gnd_3 net@349 net@634 gnd_28 NMOS L=1.2U W=6U AS=54.84P AD=72.54P PS=51.6U PD=63.6U
Mnmos@32 net@634 net@637 gnd_3 gnd_28 NMOS L=1.2U W=6U AS=72.54P AD=54.84P PS=63.6U PD=51.6U
Mnmos@35 gnd_4 A3 net@712 gnd_28 NMOS L=1.2U W=12U AS=23.22P AD=117.54P PS=27.6U PD=99U
Mnmos@36 net@712 net@14 net@727 gnd_28 NMOS L=1.2U W=12U AS=49.02P AD=23.22P PS=47.8U PD=27.6U
Mnmos@37 gnd_4 net@727 net@637 gnd_28 NMOS L=1.2U W=6U AS=46.44P AD=117.54P PS=45.6U PD=99U
Mnmos@38 gnd_5 A2 net@800 gnd_28 NMOS L=1.2U W=6U AS=46.44P AD=84.24P PS=45.6U PD=74.4U
Mnmos@39 gnd_7 B2 net@809 gnd_28 NMOS L=1.2U W=6U AS=46.44P AD=84.24P PS=45.6U PD=74.4U
Mnmos@40 gnd_6 net@800 net@824 gnd_28 NMOS L=1.2U W=12U AS=23.22P AD=117.54P PS=27.6U PD=99U
Mnmos@41 net@824 B2 net@839 gnd_28 NMOS L=1.2U W=12U AS=49.02P AD=23.22P PS=47.8U PD=27.6U
Mnmos@42 gnd_6 net@839 net@844 gnd_28 NMOS L=1.2U W=6U AS=46.44P AD=117.54P PS=45.6U PD=99U
Mnmos@43 gnd_9 net@844 net@877 gnd_28 NMOS L=1.2U W=6U AS=54.84P AD=72.54P PS=51.6U PD=63.6U
Mnmos@44 net@877 net@880 gnd_9 gnd_28 NMOS L=1.2U W=6U AS=72.54P AD=54.84P PS=63.6U PD=51.6U
Mnmos@45 gnd_8 A2 net@902 gnd_28 NMOS L=1.2U W=12U AS=23.22P AD=117.54P PS=27.6U PD=99U
Mnmos@46 net@902 net@809 net@917 gnd_28 NMOS L=1.2U W=12U AS=49.02P AD=23.22P PS=47.8U PD=27.6U
Mnmos@47 gnd_8 net@917 net@880 gnd_28 NMOS L=1.2U W=6U AS=46.44P AD=117.54P PS=45.6U PD=99U
Mnmos@48 gnd_10 A1 net@972 gnd_28 NMOS L=1.2U W=6U AS=46.44P AD=84.24P PS=45.6U PD=74.4U
Mnmos@49 gnd_11 B1 net@981 gnd_28 NMOS L=1.2U W=6U AS=46.44P AD=84.24P PS=45.6U PD=74.4U
Mnmos@50 gnd_12 net@972 net@996 gnd_28 NMOS L=1.2U W=12U AS=23.22P AD=117.54P PS=27.6U PD=99U
Mnmos@51 net@996 B1 net@1011 gnd_28 NMOS L=1.2U W=12U AS=49.02P AD=23.22P PS=47.8U PD=27.6U
Mnmos@52 gnd_12 net@1011 net@1016 gnd_28 NMOS L=1.2U W=6U AS=46.44P AD=117.54P PS=45.6U PD=99U
Mnmos@53 gnd_14 net@1016 net@1049 gnd_28 NMOS L=1.2U W=6U AS=54.84P AD=72.54P PS=51.6U PD=63.6U
Mnmos@54 net@1049 net@1052 gnd_14 gnd_28 NMOS L=1.2U W=6U AS=72.54P AD=54.84P PS=63.6U PD=51.6U
Mnmos@55 gnd_13 A1 net@1074 gnd_28 NMOS L=1.2U W=12U AS=23.22P AD=117.54P PS=27.6U PD=99U
Mnmos@56 net@1074 net@981 net@1089 gnd_28 NMOS L=1.2U W=12U AS=49.02P AD=23.22P PS=47.8U PD=27.6U
Mnmos@57 gnd_13 net@1089 net@1052 gnd_28 NMOS L=1.2U W=6U AS=46.44P AD=117.54P PS=45.6U PD=99U
Mnmos@58 gnd_15 A0 net@1144 gnd_28 NMOS L=1.2U W=6U AS=46.44P AD=84.24P PS=45.6U PD=74.4U
Mnmos@59 gnd_16 B0 net@1153 gnd_28 NMOS L=1.2U W=6U AS=46.44P AD=84.24P PS=45.6U PD=74.4U
Mnmos@60 gnd_17 net@1144 net@1168 gnd_28 NMOS L=1.2U W=12U AS=23.22P AD=117.54P PS=27.6U PD=99U
Mnmos@61 net@1168 B0 net@1183 gnd_28 NMOS L=1.2U W=12U AS=49.02P AD=23.22P PS=47.8U PD=27.6U
Mnmos@62 gnd_17 net@1183 net@1188 gnd_28 NMOS L=1.2U W=6U AS=46.44P AD=117.54P PS=45.6U PD=99U
Mnmos@63 gnd_19 net@1188 net@1221 gnd_28 NMOS L=1.2U W=6U AS=54.84P AD=72.54P PS=51.6U PD=63.6U
Mnmos@64 net@1221 net@1224 gnd_19 gnd_28 NMOS L=1.2U W=6U AS=72.54P AD=54.84P PS=63.6U PD=51.6U
Mnmos@65 gnd_18 A0 net@1246 gnd_28 NMOS L=1.2U W=12U AS=23.22P AD=117.54P PS=27.6U PD=99U
Mnmos@66 net@1246 net@1153 net@1261 gnd_28 NMOS L=1.2U W=12U AS=49.02P AD=23.22P PS=47.8U PD=27.6U
Mnmos@67 gnd_18 net@1261 net@1224 gnd_28 NMOS L=1.2U W=6U AS=46.44P AD=117.54P PS=45.6U PD=99U
Mnmos@68 gnd_20 net@634 net@1331 gnd_28 NMOS L=1.2U W=12U AS=23.22P AD=117.54P PS=27.6U PD=99U
Mnmos@69 net@1331 net@844 net@1346 gnd_28 NMOS L=1.2U W=12U AS=49.02P AD=23.22P PS=47.8U PD=27.6U
Mnmos@70 gnd_20 net@1346 net@1351 gnd_28 NMOS L=1.2U W=6U AS=46.44P AD=117.54P PS=45.6U PD=99U
Mnmos@71 gnd_21 net@634 net@1409 gnd_28 NMOS L=1.2U W=12U AS=23.22P AD=117.54P PS=27.6U PD=99U
Mnmos@72 net@1409 net@880 net@1394 gnd_28 NMOS L=1.2U W=12U AS=49.02P AD=23.22P PS=47.8U PD=27.6U
Mnmos@73 gnd_21 net@1394 net@1395 gnd_28 NMOS L=1.2U W=6U AS=46.44P AD=117.54P PS=45.6U PD=99U
Mnmos@74 gnd_22 net@634 net@1452 gnd_28 NMOS L=1.2U W=18U AS=34.02P AD=122.94P PS=39.6U PD=105U
Mnmos@75 net@1452 net@877 net@1451 gnd_28 NMOS L=1.2U W=18U AS=34.02P AD=34.02P PS=39.6U PD=39.6U
Mnmos@76 net@1451 net@1016 net@1459 gnd_28 NMOS L=1.2U W=18U AS=68.04P AD=34.02P PS=63.6U PD=39.6U
Mnmos@77 gnd_22 net@1459 net@1478 gnd_28 NMOS L=1.2U W=6U AS=46.44P AD=122.94P PS=45.6U PD=105U
Mnmos@78 gnd_23 net@634 net@1545 gnd_28 NMOS L=1.2U W=18U AS=34.02P AD=122.94P PS=39.6U PD=105U
Mnmos@79 net@1545 net@877 net@1544 gnd_28 NMOS L=1.2U W=18U AS=34.02P AD=34.02P PS=39.6U PD=39.6U
Mnmos@80 net@1544 net@1052 net@1552 gnd_28 NMOS L=1.2U W=18U AS=68.04P AD=34.02P PS=63.6U PD=39.6U
Mnmos@81 gnd_23 net@1552 net@1571 gnd_28 NMOS L=1.2U W=6U AS=46.44P AD=122.94P PS=45.6U PD=105U
Mnmos@82 net@1638 net@877 net@1639 gnd_28 NMOS L=1.2U W=24U AS=44.82P AD=44.82P PS=51.6U PD=51.6U
Mnmos@83 net@1639 net@1049 net@1668 gnd_28 NMOS L=1.2U W=24U AS=44.82P AD=44.82P PS=51.6U PD=51.6U
Mnmos@84 net@1668 net@1188 net@1640 gnd_28 NMOS L=1.2U W=24U AS=72.36P AD=44.82P PS=67.2U PD=51.6U
Mnmos@85 gnd_24 net@634 net@1638 gnd_28 NMOS L=1.2U W=24U AS=44.82P AD=128.34P PS=51.6U PD=111U
Mnmos@86 gnd_24 net@1640 net@1684 gnd_28 NMOS L=1.2U W=6U AS=46.44P AD=128.34P PS=45.6U PD=111U
Mnmos@87 net@1764 net@877 net@1765 gnd_28 NMOS L=1.2U W=24U AS=44.82P AD=44.82P PS=51.6U PD=51.6U
Mnmos@88 net@1765 net@1049 net@1794 gnd_28 NMOS L=1.2U W=24U AS=44.82P AD=44.82P PS=51.6U PD=51.6U
Mnmos@89 net@1794 net@1224 net@1766 gnd_28 NMOS L=1.2U W=24U AS=72.36P AD=44.82P PS=67.2U PD=51.6U
Mnmos@90 gnd_25 net@634 net@1764 gnd_28 NMOS L=1.2U W=24U AS=44.82P AD=128.34P PS=51.6U PD=111U
Mnmos@91 gnd_25 net@1766 net@1810 gnd_28 NMOS L=1.2U W=6U AS=46.44P AD=128.34P PS=45.6U PD=111U
Mnmos@92 net@1886 net@877 net@1887 gnd_28 NMOS L=1.2U W=24U AS=44.82P AD=44.82P PS=51.6U PD=51.6U
Mnmos@93 net@1887 net@1049 net@1916 gnd_28 NMOS L=1.2U W=24U AS=44.82P AD=44.82P PS=51.6U PD=51.6U
Mnmos@94 net@1916 net@1221 net@1888 gnd_28 NMOS L=1.2U W=24U AS=72.36P AD=44.82P PS=67.2U PD=51.6U
Mnmos@95 gnd_26 net@634 net@1886 gnd_28 NMOS L=1.2U W=24U AS=44.82P AD=128.34P PS=51.6U PD=111U
Mnmos@96 gnd_26 net@1888 Equal gnd_28 NMOS L=1.2U W=6U AS=46.44P AD=128.34P PS=45.6U PD=111U
Mnmos@97 net@1983 net@349 gnd_27 gnd_28 NMOS L=1.2U W=6U AS=82.08P AD=72.36P PS=69.36U PD=67.2U
Mnmos@98 net@1983 net@1351 gnd_27 gnd_28 NMOS L=1.2U W=6U AS=82.08P AD=72.36P PS=69.36U PD=67.2U
Mnmos@99 net@1983 net@1478 gnd_27 gnd_28 NMOS L=1.2U W=6U AS=82.08P AD=72.36P PS=69.36U PD=67.2U
Mnmos@100 net@1983 net@1684 gnd_27 gnd_28 NMOS L=1.2U W=6U AS=82.08P AD=72.36P PS=69.36U PD=67.2U
Mnmos@101 gnd_27 net@1983 LessThan gnd_28 NMOS L=1.2U W=6U AS=46.44P AD=82.08P PS=45.6U PD=69.36U
Mnmos@102 net@2088 net@637 gnd_28 gnd_28 NMOS L=1.2U W=6U AS=82.08P AD=72.36P PS=69.36U PD=67.2U
Mnmos@103 net@2088 net@1395 gnd_28 gnd_28 NMOS L=1.2U W=6U AS=82.08P AD=72.36P PS=69.36U PD=67.2U
Mnmos@104 net@2088 net@1571 gnd_28 gnd_28 NMOS L=1.2U W=6U AS=82.08P AD=72.36P PS=69.36U PD=67.2U
Mnmos@105 net@2088 net@1810 gnd_28 gnd_28 NMOS L=1.2U W=6U AS=82.08P AD=72.36P PS=69.36U PD=67.2U
Mnmos@106 gnd_28 net@2088 GreaterThan gnd_28 NMOS L=1.2U W=6U AS=46.44P AD=82.08P PS=45.6U PD=69.36U
Mpmos@0 vdd A3 net@10 vdd_28 PMOS L=1.2U W=12U AS=46.44P AD=113.04P PS=45.6U PD=98.4U
Mpmos@1 vdd_1 B3 net@14 vdd_28 PMOS L=1.2U W=12U AS=46.44P AD=113.04P PS=45.6U PD=98.4U
Mpmos@5 vdd_2 net@10 net@344 vdd_28 PMOS L=1.2U W=12U AS=49.02P AD=105.42P PS=47.8U PD=91.4U
Mpmos@6 net@344 B3 vdd_2 vdd_28 PMOS L=1.2U W=12U AS=105.42P AD=49.02P PS=91.4U PD=47.8U
Mpmos@7 vdd_2 net@344 net@349 vdd_28 PMOS L=1.2U W=12U AS=46.44P AD=105.42P PS=45.6U PD=91.4U
Mpmos@23 vdd_3 net@349 net@650 vdd_28 PMOS L=1.2U W=24U AS=44.82P AD=181.44P PS=51.6U PD=153.6U
Mpmos@24 net@650 net@637 net@634 vdd_28 PMOS L=1.2U W=24U AS=54.84P AD=44.82P PS=51.6U PD=51.6U
Mpmos@27 vdd_4 A3 net@727 vdd_28 PMOS L=1.2U W=12U AS=49.02P AD=105.42P PS=47.8U PD=91.4U
Mpmos@28 net@727 net@14 vdd_4 vdd_28 PMOS L=1.2U W=12U AS=105.42P AD=49.02P PS=91.4U PD=47.8U
Mpmos@29 vdd_4 net@727 net@637 vdd_28 PMOS L=1.2U W=12U AS=46.44P AD=105.42P PS=45.6U PD=91.4U
Mpmos@30 vdd_5 A2 net@800 vdd_28 PMOS L=1.2U W=12U AS=46.44P AD=113.04P PS=45.6U PD=98.4U
Mpmos@31 vdd_7 B2 net@809 vdd_28 PMOS L=1.2U W=12U AS=46.44P AD=113.04P PS=45.6U PD=98.4U
Mpmos@32 vdd_6 net@800 net@839 vdd_28 PMOS L=1.2U W=12U AS=49.02P AD=105.42P PS=47.8U PD=91.4U
Mpmos@33 net@839 B2 vdd_6 vdd_28 PMOS L=1.2U W=12U AS=105.42P AD=49.02P PS=91.4U PD=47.8U
Mpmos@34 vdd_6 net@839 net@844 vdd_28 PMOS L=1.2U W=12U AS=46.44P AD=105.42P PS=45.6U PD=91.4U
Mpmos@35 vdd_9 net@844 net@891 vdd_28 PMOS L=1.2U W=24U AS=44.82P AD=181.44P PS=51.6U PD=153.6U
Mpmos@36 net@891 net@880 net@877 vdd_28 PMOS L=1.2U W=24U AS=54.84P AD=44.82P PS=51.6U PD=51.6U
Mpmos@37 vdd_8 A2 net@917 vdd_28 PMOS L=1.2U W=12U AS=49.02P AD=105.42P PS=47.8U PD=91.4U
Mpmos@38 net@917 net@809 vdd_8 vdd_28 PMOS L=1.2U W=12U AS=105.42P AD=49.02P PS=91.4U PD=47.8U
Mpmos@39 vdd_8 net@917 net@880 vdd_28 PMOS L=1.2U W=12U AS=46.44P AD=105.42P PS=45.6U PD=91.4U
Mpmos@40 vdd_10 A1 net@972 vdd_28 PMOS L=1.2U W=12U AS=46.44P AD=113.04P PS=45.6U PD=98.4U
Mpmos@41 vdd_11 B1 net@981 vdd_28 PMOS L=1.2U W=12U AS=46.44P AD=113.04P PS=45.6U PD=98.4U
Mpmos@42 vdd_12 net@972 net@1011 vdd_28 PMOS L=1.2U W=12U AS=49.02P AD=105.42P PS=47.8U PD=91.4U
Mpmos@43 net@1011 B1 vdd_12 vdd_28 PMOS L=1.2U W=12U AS=105.42P AD=49.02P PS=91.4U PD=47.8U
Mpmos@44 vdd_12 net@1011 net@1016 vdd_28 PMOS L=1.2U W=12U AS=46.44P AD=105.42P PS=45.6U PD=91.4U
Mpmos@45 vdd_14 net@1016 net@1063 vdd_28 PMOS L=1.2U W=24U AS=44.82P AD=181.44P PS=51.6U PD=153.6U
Mpmos@46 net@1063 net@1052 net@1049 vdd_28 PMOS L=1.2U W=24U AS=54.84P AD=44.82P PS=51.6U PD=51.6U
Mpmos@47 vdd_13 A1 net@1089 vdd_28 PMOS L=1.2U W=12U AS=49.02P AD=105.42P PS=47.8U PD=91.4U
Mpmos@48 net@1089 net@981 vdd_13 vdd_28 PMOS L=1.2U W=12U AS=105.42P AD=49.02P PS=91.4U PD=47.8U
Mpmos@49 vdd_13 net@1089 net@1052 vdd_28 PMOS L=1.2U W=12U AS=46.44P AD=105.42P PS=45.6U PD=91.4U
Mpmos@50 vdd_15 A0 net@1144 vdd_28 PMOS L=1.2U W=12U AS=46.44P AD=113.04P PS=45.6U PD=98.4U
Mpmos@51 vdd_16 B0 net@1153 vdd_28 PMOS L=1.2U W=12U AS=46.44P AD=113.04P PS=45.6U PD=98.4U
Mpmos@52 vdd_17 net@1144 net@1183 vdd_28 PMOS L=1.2U W=12U AS=49.02P AD=105.42P PS=47.8U PD=91.4U
Mpmos@53 net@1183 B0 vdd_17 vdd_28 PMOS L=1.2U W=12U AS=105.42P AD=49.02P PS=91.4U PD=47.8U
Mpmos@54 vdd_17 net@1183 net@1188 vdd_28 PMOS L=1.2U W=12U AS=46.44P AD=105.42P PS=45.6U PD=91.4U
Mpmos@55 vdd_19 net@1188 net@1235 vdd_28 PMOS L=1.2U W=24U AS=44.82P AD=181.44P PS=51.6U PD=153.6U
Mpmos@56 net@1235 net@1224 net@1221 vdd_28 PMOS L=1.2U W=24U AS=54.84P AD=44.82P PS=51.6U PD=51.6U
Mpmos@57 vdd_18 A0 net@1261 vdd_28 PMOS L=1.2U W=12U AS=49.02P AD=105.42P PS=47.8U PD=91.4U
Mpmos@58 net@1261 net@1153 vdd_18 vdd_28 PMOS L=1.2U W=12U AS=105.42P AD=49.02P PS=91.4U PD=47.8U
Mpmos@59 vdd_18 net@1261 net@1224 vdd_28 PMOS L=1.2U W=12U AS=46.44P AD=105.42P PS=45.6U PD=91.4U
Mpmos@60 vdd_20 net@634 net@1346 vdd_28 PMOS L=1.2U W=12U AS=49.02P AD=105.42P PS=47.8U PD=91.4U
Mpmos@61 net@1346 net@844 vdd_20 vdd_28 PMOS L=1.2U W=12U AS=105.42P AD=49.02P PS=91.4U PD=47.8U
Mpmos@62 vdd_20 net@1346 net@1351 vdd_28 PMOS L=1.2U W=12U AS=46.44P AD=105.42P PS=45.6U PD=91.4U
Mpmos@63 vdd_21 net@634 net@1394 vdd_28 PMOS L=1.2U W=12U AS=49.02P AD=105.42P PS=47.8U PD=91.4U
Mpmos@64 net@1394 net@880 vdd_21 vdd_28 PMOS L=1.2U W=12U AS=105.42P AD=49.02P PS=91.4U PD=47.8U
Mpmos@65 vdd_21 net@1394 net@1395 vdd_28 PMOS L=1.2U W=12U AS=46.44P AD=105.42P PS=45.6U PD=91.4U
Mpmos@66 vdd_22 net@634 net@1459 vdd_28 PMOS L=1.2U W=12U AS=68.04P AD=109.89P PS=63.6U PD=93.3U
Mpmos@67 vdd_22 net@877 net@1459 vdd_28 PMOS L=1.2U W=12U AS=68.04P AD=109.89P PS=63.6U PD=93.3U
Mpmos@68 vdd_22 net@1016 net@1459 vdd_28 PMOS L=1.2U W=12U AS=68.04P AD=109.89P PS=63.6U PD=93.3U
Mpmos@69 vdd_22 net@1459 net@1478 vdd_28 PMOS L=1.2U W=12U AS=46.44P AD=109.89P PS=45.6U PD=93.3U
Mpmos@70 vdd_23 net@634 net@1552 vdd_28 PMOS L=1.2U W=12U AS=68.04P AD=109.89P PS=63.6U PD=93.3U
Mpmos@71 vdd_23 net@877 net@1552 vdd_28 PMOS L=1.2U W=12U AS=68.04P AD=109.89P PS=63.6U PD=93.3U
Mpmos@72 vdd_23 net@1052 net@1552 vdd_28 PMOS L=1.2U W=12U AS=68.04P AD=109.89P PS=63.6U PD=93.3U
Mpmos@73 vdd_23 net@1552 net@1571 vdd_28 PMOS L=1.2U W=12U AS=46.44P AD=109.89P PS=45.6U PD=93.3U
Mpmos@74 vdd_24 net@634 net@1640 vdd_28 PMOS L=1.2U W=12U AS=72.36P AD=109.08P PS=67.2U PD=92.16U
Mpmos@75 vdd_24 net@877 net@1640 vdd_28 PMOS L=1.2U W=12U AS=72.36P AD=109.08P PS=67.2U PD=92.16U
Mpmos@76 vdd_24 net@1049 net@1640 vdd_28 PMOS L=1.2U W=12U AS=72.36P AD=109.08P PS=67.2U PD=92.16U
Mpmos@77 vdd_24 net@1188 net@1640 vdd_28 PMOS L=1.2U W=12U AS=72.36P AD=109.08P PS=67.2U PD=92.16U
Mpmos@78 vdd_24 net@1640 net@1684 vdd_28 PMOS L=1.2U W=12U AS=46.44P AD=109.08P PS=45.6U PD=92.16U
Mpmos@79 vdd_25 net@634 net@1766 vdd_28 PMOS L=1.2U W=12U AS=72.36P AD=109.08P PS=67.2U PD=92.16U
Mpmos@80 vdd_25 net@877 net@1766 vdd_28 PMOS L=1.2U W=12U AS=72.36P AD=109.08P PS=67.2U PD=92.16U
Mpmos@81 vdd_25 net@1049 net@1766 vdd_28 PMOS L=1.2U W=12U AS=72.36P AD=109.08P PS=67.2U PD=92.16U
Mpmos@82 vdd_25 net@1224 net@1766 vdd_28 PMOS L=1.2U W=12U AS=72.36P AD=109.08P PS=67.2U PD=92.16U
Mpmos@83 vdd_25 net@1766 net@1810 vdd_28 PMOS L=1.2U W=12U AS=46.44P AD=109.08P PS=45.6U PD=92.16U
Mpmos@84 vdd_26 net@634 net@1888 vdd_28 PMOS L=1.2U W=12U AS=72.36P AD=109.08P PS=67.2U PD=92.16U
Mpmos@85 vdd_26 net@877 net@1888 vdd_28 PMOS L=1.2U W=12U AS=72.36P AD=109.08P PS=67.2U PD=92.16U
Mpmos@86 vdd_26 net@1049 net@1888 vdd_28 PMOS L=1.2U W=12U AS=72.36P AD=109.08P PS=67.2U PD=92.16U
Mpmos@87 vdd_26 net@1221 net@1888 vdd_28 PMOS L=1.2U W=12U AS=72.36P AD=109.08P PS=67.2U PD=92.16U
Mpmos@88 vdd_26 net@1888 Equal vdd_28 PMOS L=1.2U W=12U AS=46.44P AD=109.08P PS=45.6U PD=92.16U
Mpmos@89 net@1980 net@1351 net@1981 vdd_28 PMOS L=1.2U W=48U AS=88.02P AD=88.02P PS=99.6U PD=99.6U
Mpmos@90 net@1981 net@1478 net@2012 vdd_28 PMOS L=1.2U W=48U AS=88.02P AD=88.02P PS=99.6U PD=99.6U
Mpmos@91 vdd_27 net@349 net@1980 vdd_28 PMOS L=1.2U W=48U AS=88.02P AD=200.34P PS=99.6U PD=171U
Mpmos@92 net@2012 net@1684 net@1983 vdd_28 PMOS L=1.2U W=48U AS=72.36P AD=88.02P PS=67.2U PD=99.6U
Mpmos@93 vdd_27 net@1983 LessThan vdd_28 PMOS L=1.2U W=12U AS=46.44P AD=200.34P PS=45.6U PD=171U
Mpmos@94 net@2085 net@1395 net@2086 vdd_28 PMOS L=1.2U W=48U AS=88.02P AD=88.02P PS=99.6U PD=99.6U
Mpmos@95 net@2086 net@1571 net@2117 vdd_28 PMOS L=1.2U W=48U AS=88.02P AD=88.02P PS=99.6U PD=99.6U
Mpmos@96 vdd_28 net@637 net@2085 vdd_28 PMOS L=1.2U W=48U AS=88.02P AD=200.34P PS=99.6U PD=171U
Mpmos@97 net@2117 net@1810 net@2088 vdd_28 PMOS L=1.2U W=48U AS=72.36P AD=88.02P PS=67.2U PD=99.6U
Mpmos@98 vdd_28 net@2088 GreaterThan vdd_28 PMOS L=1.2U W=12U AS=46.44P AD=200.34P PS=45.6U PD=171U

* Spice Code nodes in cell cell 'Test_4_Comparator{lay}'
vdd vdd 0 DC 5
vdd1 vdd_1 0 DC 5
vdd2 vdd_2 0 DC 5
vdd3 vdd_3 0 DC 5
vdd4 vdd_4 0 DC 5
vdd5 vdd_5 0 DC 5
vdd6 vdd_6 0 DC 5
vdd7 vdd_7 0 DC 5
vdd8 vdd_8 0 DC 5
vdd9 vdd_9 0 DC 5
vdd10 vdd_10 0 DC 5
vdd11 vdd_11 0 DC 5
vdd12 vdd_12 0 DC 5
vdd13 vdd_13 0 DC 5
vdd14 vdd_14 0 DC 5
vdd15 vdd_15 0 DC 5
vdd16 vdd_16 0 DC 5
vdd17 vdd_17 0 DC 5
vdd18 vdd_18 0 DC 5
vdd19 vdd_19 0 DC 5
vdd20 vdd_20 0 DC 5
vdd21 vdd_21 0 DC 5
vdd22 vdd_22 0 DC 5
vdd23 vdd_23 0 DC 5
vdd24 vdd_24 0 DC 5
vdd25 vdd_25 0 DC 5
vdd26 vdd_26 0 DC 5
vdd27 vdd_27 0 DC 5
vdd28 vdd_28 0 DC 5
v3 A3 0 pwl 5n 0 10n 0 20n 5 50n 5 60n 0 70n 5 80n 5 100n 0
vb3 B3 0 pwl 5n 0 10n 5 20n 0 50n 0 60n 5 80n 5 100n 0
va2 A2 0 pwl 5n 0 10n 0 20n 5 50n 5 60n 0 70n 5 80n 5 100n 0
vb2 B2 0 pwl 5n 0 10n 5 20n 0 50n 0 60n 5 80n 5 100n 0
va1 A1 0 pwl 5n 0 10n 0 20n 5 50n 5 60n 0 70n 5 80n 5 100n 0
vb1 B1 0 pwl 5n 0 10n 5 20n 0 50n 0 60n 5 80n 5 100n 0
va0 A0 0 pwl 5n 0 10n 0 20n 5 50n 5 60n 0 70n 5 80n 5 100n 0
vb0 B0 0 pwl 5n 0 10n 5 20n 0 50n 0 60n 5 80n 5 100n 0
cload1 GreaterThan 0 250fF
.measure tran tf1 trig v(GreaterThan) val= 4.5 fall=1 td=1ns targ v(GreaterThan) val=0.5 fall=1
.measure tran tr1 trig v(GreaterThan) val= 0.5 rise=1 td=5ns targ v(GreaterThan) val=4.5 rise=1
cload2 LessThan 0 250fF
.measure tran tf2 trig v(LessThan) val= 4.5 fall=1 td=1ns targ v(LessThan) val=0.5 fall=1
.measure tran tr2 trig v(LessThan) val= 0.5 rise=1 td=5ns targ v(LessThan) val=4.5 rise=1
cloa3 Equal 0 250fF
.measure tran tf3 trig v(Equal) val= 4.5 fall=1 td=1ns targ v(Equal) val=0.5 fall=1
.measure tran tr3 trig v(Equal) val= 0.5 rise=1 td=5ns targ v(Equal) val=4.5 rise=1
.tran 0 0.1us
.include C:\LTspice\C5_models.txt
.END
